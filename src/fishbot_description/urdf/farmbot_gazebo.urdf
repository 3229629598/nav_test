Commit message: 0

File: src/fishbot_description/urdf/farmbot_gazebo.urdf (robot description, URDF)
Before this commit: robot fishbot, 8 links, 7 joints
Links:
- link base_link: geometry collision box size=0.2 0.2 0.12; visual box size=0.2 0.2 0.12
